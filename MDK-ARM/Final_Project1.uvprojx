# Keil uVision project Final_Project1.uvprojx, settings and files
target Final_Project1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F303VC STMicroelectronics
  cpu: IRAM(0x20000000-0x20009FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: Final_Project1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC
  c include: ../Inc;                                     ../Drivers/STM32F3xx_HAL_Driver/Inc;                                     ../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;                                     ../Drivers/CMSIS/Device/ST/STM32F3xx/Include;                                     ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xa000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_spi.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_tim.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pcd.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_adc.c
  group Application/User
    ../Src/: stm32f3xx_it.c stm32f3xx_hal_msp.c main.c LiquidCrystal.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Inc
    ../Inc/: LiquidCrystal.h
software components: CMSIS:CORE 4.3.0
